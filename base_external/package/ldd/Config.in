## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Build and install the Linux Device Drivers examples
	  (misc-modules + scull).
```
